File: Voyager.kicad_pcb (KiCad board)
At the start: 2 copper layers, 285 x 94.6 mm, 258 parts, among them Q1 NSS40301MZ4T1G, SW1 SW_PUSH, U1 ATMEGA32U2-AU, Y1 16MHz

Commit message: Unroute all for revisions
Routing:
- net +5V: track 1886.3 -> 0.00 mm, vias 4 -> 0
- net LEDGND: track 1297.1 -> 0.00 mm, vias 13 -> 0
- net GND: track 1150.1 -> 0.00 mm, vias 45 -> 0
- net ROW8: track 366.4 -> 0.00 mm, vias 4 -> 0
- net ROW0: track 350.6 -> 0.00 mm, vias 4 -> 0
- net COL6: track 342.8 -> 0.00 mm, vias 3 -> 0
- net ROW9: track 332.7 -> 0.00 mm, vias 6 -> 0
- net COL5: track 323.9 -> 0.00 mm, vias 3 -> 0
- net ROW1: track 317.6 -> 0.00 mm, vias 2 -> 0
- net ROW3: track 315.2 -> 0.00 mm, vias 2 -> 0
- net COL7: track 303.7 -> 0.00 mm, vias 3 -> 0
- net ROW2: track 294.2 -> 0.00 mm, vias 2 -> 0
- net ROW6: track 277.9 -> 0.00 mm, vias 2 -> 0
- net ROW5: track 276.0 -> 0.00 mm, vias 2 -> 0
- net ROW4: track 273.8 -> 0.00 mm, vias 2 -> 0
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- removed copper zone on B.Cu, net GND
- removed copper zone on F.Cu, net GND

Commit message: Move some diodes
Parts:
- D_#0_1, D_#1, D_#2, D_#3, D_#4, D_#5, D_#6, D_#7, D_#8, D_#9, D_'1, D_,1, D_-1, D_.1, D_/1, D_;1, D_=1, D_A1, D_ALT1, D_B1, D_BACK1, D_C1, D_CAPS1, D_CTRL1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: footprint Diodes_SMD:D_SMA -> Diodes_SMD:D_SOD-323_HandSoldering
- moved R_=1 15.5 mm to (295.3, 61.9), turned to 180 degrees
- moved D_=1 15.2 mm to (277.8, 53.2)
- moved D_BACK1 7.69 mm to (296.9, 53.2), turned to 270 degrees
- moved D_DEL1 3.58 mm to (293.7, 53.2)
- moved R_-1 3.57 mm to (276.2, 61.9), turned to 180 degrees
- moved R_#0_1 3.57 mm to (257.2, 61.9), turned to 180 degrees
- moved R_#2 3.57 mm to (104.8, 61.9), turned to 180 degrees
- moved R_#4 3.57 mm to (142.9, 61.9), turned to 180 degrees
- moved R_#6 3.57 mm to (181.0, 61.9), turned to 180 degrees
- moved R_#9 3.57 mm to (238.1, 61.9), turned to 180 degrees
- moved R_#8 3.57 mm to (219.1, 61.9), turned to 180 degrees
- moved D_-1 1.64 mm to (274.6, 53.2)
- moved D_W1 1.59 mm to (114.3, 72.2)
- moved D_Q1 0.40 mm to (95.2, 73.0)
- moved D_#0_1 0.40 mm to (257.2, 53.2)
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Other:
- board text removed: "Isolate the entire GND trace on top both sides On bottom on right"

Commit message: Move more diodes and resistors
Parts:
- moved D_ENTER1 18.9 mm to (292.1, 91.3), turned to 270 degrees
- moved D_G1 17.6 mm to (158.8, 91.3), turned to 270 degrees
- moved R_\1 16.9 mm to (311.1, 81.8), turned to 0 degrees
- moved D_ESC1 16.2 mm to (54.8, 72.2), turned to 270 degrees
- moved D_'1 15.2 mm to (273.1, 91.3)
- moved R_]1 13.9 mm to (303.2, 81.8), turned to 180 degrees
- moved D_RSHIFT1 12.6 mm to (314.3, 110.3), turned to 270 degrees
- moved D_CAPS1 4.42 mm to (70.6, 91.3), turned to 270 degrees
- moved R_A1 3.91 mm to (100.0, 98.4), turned to 90 degrees
- moved R_D1 3.91 mm to (138.1, 98.4), turned to 90 degrees
- moved R_E1 3.91 mm to (133.3, 79.4), turned to 90 degrees
- moved R_I1 3.91 mm to (228.6, 79.4), turned to 90 degrees
- moved R_J1 3.91 mm to (214.3, 98.4), turned to 90 degrees
- moved R_K1 3.91 mm to (233.4, 98.4), turned to 90 degrees
- moved R_L1 3.91 mm to (252.4, 98.4), turned to 90 degrees
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
Commit message: Fix all placements of diodes and resistors
Parts:
- moved R_`1 13.2 mm to (273.8, 136.5), turned to 90 degrees
- moved R_DEL1 12.8 mm to (296.9, 60.3), turned to 90 degrees
- moved R_UP1 6.19 mm to (291.3, 117.5)
- moved D_SPACE1 4.54 mm to (199.2, 129.4)
- moved R_B1 3.91 mm to (185.7, 117.5), turned to 90 degrees
- moved R_X1 3.91 mm to (128.6, 117.5), turned to 90 degrees
- moved R_Z1 3.91 mm to (109.5, 117.5)
- moved R_C1 3.91 mm to (147.6, 117.5), turned to 90 degrees
- moved R_CTRL1 3.20 mm to (70.6, 136.5), turned to 90 degrees
- moved R_WIN1 3.20 mm to (96.8, 136.5), turned to 90 degrees
- moved D_ALT1 2.99 mm to (122.2, 129.4)
- moved R_ALT1 2.54 mm to (122.2, 136.5), turned to 90 degrees
- moved R_FN1 2.54 mm to (255.6, 136.5), turned to 90 degrees
- moved R_LEFT1 2.48 mm to (277.8, 136.5), turned to 90 degrees
- moved R_ISO\1 2.40 mm to (88.1, 117.5), turned to 90 degrees
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
Commit message: Fix remaining diodes
All diodes upright and facing same direction to reduce mistakes
Parts:
- moved D_\1 17.5 mm to (325.4, 72.2), turned to 270 degrees
- moved R_\1 2.86 mm to (313.5, 80.2), turned to 90 degrees
- moved R_]1 2.25 mm to (301.6, 80.2), turned to 90 degrees
- moved D_RSHIFT1 0.79 mm to (315.1, 110.3)
Changed lines of the file:
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@@
   )
   (module Resistors_SMD:R_0805_HandSoldering (layer B.Cu)
-    (at 311.15 81.75625)
+    (at 313.53125 80.16875 90)
     (descr "Resistor SMD 0805, hand soldering")
     (tags "resistor 0805")
     (attr smd)
-    (fp_text reference R_\1 (at -0.3175 1.8415) (layer B.SilkS)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text value 2.7k (at 0 -1.75) (layer B.Fab)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user %R (at 0 0) (layer B.Fab)
+    (fp_text reference R_\1 (at -0.3175 1.8415 90) (layer B.SilkS)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text value 2.7k (at 0 -1.75 90) (layer B.Fab)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user %R (at 0 0 90) (layer B.Fab)
       (effects (font (size 0.5 0.5) (thickness 0.075)) (justify mirror))
     )
@@
     (fp_line (start 2.35 -0.9) (end 2.35 0.9) (layer B.CrtYd) (width 0.05))
     (fp_line (start 2.35 -0.9) (end -2.35 -0.9) (layer B.CrtYd) (width 0.05))
-    (pad 1 smd rect (at -1.35 0) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
+    (pad 1 smd rect (at -1.35 0 90) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
       (net 157 LEDGND))
-    (pad 2 smd rect (at 1.35 0) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
+    (pad 2 smd rect (at 1.35 0 90) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
       (net 154 "Net-(K_\\1-Pad4)"))
     (model ${KISYS3DMOD}/Resistors_SMD.3dshapes/R_0805.wrl
@@
   )
   (module Resistors_SMD:R_0805_HandSoldering (layer B.Cu)
-    (at 303.2125 81.75625 180)
+    (at 301.625 80.16875 90)
     (descr "Resistor SMD 0805, hand soldering")
     (tags "resistor 0805")
     (attr smd)
-    (fp_text reference R_]1 (at 0 1.7 180) (layer B.SilkS)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text value 2.7k (at 0 -1.75 180) (layer B.Fab)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user %R (at 0 0 180) (layer B.Fab)
+    (fp_text reference R_]1 (at 0 1.7 90) (layer B.SilkS)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text value 2.7k (at 0 -1.75 90) (layer B.Fab)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user %R (at 0 0 90) (layer B.Fab)
       (effects (font (size 0.5 0.5) (thickness 0.075)) (justify mirror))
     )
@@
     (fp_line (start 2.35 -0.9) (end 2.35 0.9) (layer B.CrtYd) (width 0.05))
     (fp_line (start 2.35 -0.9) (end -2.35 -0.9) (layer B.CrtYd) (width 0.05))
-    (pad 1 smd rect (at -1.35 0 180) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
+    (pad 1 smd rect (at -1.35 0 90) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
       (net 157 LEDGND))
-    (pad 2 smd rect (at 1.35 0 180) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
+    (pad 2 smd rect (at 1.35 0 90) (size 1.5 1.3) (layers B.Cu B.Paste B.Mask)
       (net 155 "Net-(K_]1-Pad4)"))
     (model ${KISYS3DMOD}/Resistors_SMD.3dshapes/R_0805.wrl
@@
   )
   (module Diodes_SMD:D_SOD-323_HandSoldering (layer B.Cu)
-    (at 314.325 110.33125 270)
+    (at 315.11875 110.33125 270)
     (descr SOD-323)
     (tags SOD-323)
@@
   )
   (module Diodes_SMD:D_SOD-323_HandSoldering (layer B.Cu)
-    (at 307.975 70.64375)
-    (descr SOD-323)
-    (tags SOD-323)
-    (attr smd)
-    (fp_text reference D_\1 (at 0 1.85) (layer B.SilkS)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text value SMA-GENERIC (at 0.1 -1.9) (layer B.Fab)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user %R (at 0 1.85) (layer B.Fab)
-      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_line (start -1.9 0.85) (end -1.9 -0.85) (layer B.SilkS) (width 0.12))
-    (fp_line (start 0.2 0) (end 0.45 0) (layer B.Fab) (width 0.1))
-    (fp_line (start 0.2 -0.35) (end -0.3 0) (layer B.Fab) (width 0.1))
-    (fp_line (start 0.2 0.35) (end 0.2 -0.35) (layer B.Fab) (width 0.1))
-    (fp_line (start -0.3 0) (end 0.2 0.35) (layer B.Fab) (width 0.1))
-    (fp_line (start -0.3 0) (end -0.5 0) (layer B.Fab) (width 0.1))
-    (fp_line (start -0.3 0.35) (end -0.3 -0.35) (layer B.Fab) (width 0.1))
-    (fp_line (start -0.9 -0.7) (end -0.9 0.7) (layer B.Fab) (width 0.1))
-    (fp_line (start 0.9 -0.7) (end -0.9 -0.7) (layer B.Fab) (width 0.1))
-    (fp_line (start 0.9 0.7) (end 0.9 -0.7) (layer B.Fab) (width 0.1))
-    (fp_line (start -0.9 0.7) (end 0.9 0.7) (layer B.Fab) (width 0.1))
-    (fp_line (start -2 0.95) (end 2 0.95) (layer B.CrtYd) (width 0.05))
-    (fp_line (start 2 0.95) (end 2 -0.95) (layer B.CrtYd) (width 0.05))
-    (fp_line (start -2 -0.95) (end 2 -0.95) (layer B.CrtYd) (width 0.05))
-    (fp_line (start -2 0.95) (end -2 -0.95) (layer B.CrtYd) (width 0.05))
-    (fp_line (start -1.9 -0.85) (end 1.25 -0.85) (layer B.SilkS) (width 0.12))
-    (fp_line (start -1.9 0.85) (end 1.25 0.85) (layer B.SilkS) (width 0.12))
-    (pad 1 smd rect (at -1.25 0) (size 1 1) (layers B.Cu B.Paste B.Mask)
+    (at 325.4375 72.23125 270)
+    (descr SOD-323)
+    (tags SOD-323)
+    (attr smd)
+    (fp_text reference D_\1 (at 0 1.85 270) (layer B.SilkS)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text value SMA-GENERIC (at 0.1 -1.9 270) (layer B.Fab)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user %R (at 0 1.85 270) (layer B.Fab)
+      (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_line (start -1.9 0.85) (end -1.9 -0.85) (layer B.SilkS) (width 0.12))
+    (fp_line (start 0.2 0) (end 0.45 0) (layer B.Fab) (width 0.1))
+    (fp_line (start 0.2 -0.35) (end -0.3 0) (layer B.Fab) (width 0.1))
+    (fp_line (start 0.2 0.35) (end 0.2 -0.35) (layer B.Fab) (width 0.1))
+    (fp_line (start -0.3 0) (end 0.2 0.35) (layer B.Fab) (width 0.1))
+    (fp_line (start -0.3 0) (end -0.5 0) (layer B.Fab) (width 0.1))
+    (fp_line (start -0.3 0.35) (end -0.3 -0.35) (layer B.Fab) (width 0.1))
+    (fp_line (start -0.9 -0.7) (end -0.9 0.7) (layer B.Fab) (width 0.1))
+    (fp_line (start 0.9 -0.7) (end -0.9 -0.7) (layer B.Fab) (width 0.1))
+    (fp_line (start 0.9 0.7) (end 0.9 -0.7) (layer B.Fab) (width 0.1))
+    (fp_line (start -0.9 0.7) (end 0.9 0.7) (layer B.Fab) (width 0.1))
+    (fp_line (start -2 0.95) (end 2 0.95) (layer B.CrtYd) (width 0.05))
+    (fp_line (start 2 0.95) (end 2 -0.95) (layer B.CrtYd) (width 0.05))
+    (fp_line (start -2 -0.95) (end 2 -0.95) (layer B.CrtYd) (width 0.05))
+    (fp_line (start -2 0.95) (end -2 -0.95) (layer B.CrtYd) (width 0.05))
+    (fp_line (start -1.9 -0.85) (end 1.25 -0.85) (layer B.SilkS) (width 0.12))
+    (fp_line (start -1.9 0.85) (end 1.25 0.85) (layer B.SilkS) (width 0.12))
+    (pad 1 smd rect (at -1.25 0 270) (size 1 1) (layers B.Cu B.Paste B.Mask)
       (net 41 ROW2))
-    (pad 2 smd rect (at 1.25 0) (size 1 1) (layers B.Cu B.Paste B.Mask)
+    (pad 2 smd rect (at 1.25 0 270) (size 1 1) (layers B.Cu B.Paste B.Mask)
       (net 79 "Net-(D_\\1-Pad2)"))
     (model ${KISYS3DMOD}/Diodes_SMD.3dshapes/D_SOD-323.wrl

Commit message: Wire rows
Parts:
- moved D_ESC1 35.0 mm to (83.3, 53.2)
- moved D_#1 1.59 mm to (87.3, 53.2)
- moved R_#1 1.59 mm to (87.3, 60.3)
Routing:
- net ROW2: track 0.00 -> 248.6 mm
- net ROW3: track 0.00 -> 243.4 mm
- net ROW6: track 0.00 -> 237.0 mm
- net ROW5: track 0.00 -> 232.5 mm
- net ROW0: track 0.00 -> 223.8 mm
- net ROW1: track 0.00 -> 221.7 mm
- net ROW7: track 0.00 -> 213.6 mm
- net ROW4: track 0.00 -> 200.9 mm
- net ROW8: track 0.00 -> 136.7 mm
- net ROW9: track 0.00 -> 88.7 mm
- net Net-(D_SHIFT1-Pad2): track 0.00 -> 28.9 mm
- net Net-(D_ESC1-Pad2): track 0.00 -> 24.9 mm
- net COL0: track 0.00 -> 21.8 mm
- net Net-(D_RIGHT1-Pad2): track 0.00 -> 21.8 mm
- net Net-(D_TAB1-Pad2): track 0.00 -> 15.0 mm
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Other:
- net class Default: clearance 0.1524 -> 0.2032
- net class POWER: clearance 0.1524 -> 0.2032
- rule trace_clearance: 0.1524 -> 0.2032

Commit message: Connect some resistors to leds
Parts:
- turned R_ENTER1 to 90 degrees
- turned R_UP1 to 90 degrees
- turned R_Z1 to 90 degrees
Routing:
- net Net-(K_/1-Pad4): track 0.00 -> 17.1 mm
- net Net-(K_RSHIFT2-Pad4): track 0.00 -> 16.1 mm
- net Net-(K_SHIFT1-Pad4): track 0.00 -> 16.0 mm
- net Net-(K_ISO`1-Pad4): track 0.00 -> 14.5 mm
- net Net-(K_CAPS1-Pad4): track 0.00 -> 14.5 mm
- net Net-(K_BACK1-Pad4): track 0.00 -> 11.7 mm
- net Net-(K_RSHIFT1-Pad4): track 0.00 -> 11.3 mm
- net Net-(K_#1-Pad4): track 0.00 -> 11.2 mm
- net Net-(K_G1-Pad4): track 0.00 -> 10.6 mm
- net Net-(K_DEL1-Pad4): track 0.00 -> 10.6 mm
- net Net-(K_'1-Pad4): track 0.00 -> 10.6 mm
- net Net-(K_#5-Pad4): track 0.00 -> 9.66 mm
- net Net-(K_#0_1-Pad4): track 0.00 -> 9.66 mm
- net Net-(K_U1-Pad4): track 0.00 -> 9.66 mm
- net Net-(K_K1-Pad4): track 0.00 -> 9.66 mm
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