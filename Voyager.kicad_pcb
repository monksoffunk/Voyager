# Repository monksoffunk/Voyager

File README.md:

# Voyager
Voyager 60% Keyboard PCB

A simple MX/Alps 60% board that just works.
Revision 1.0 released 2017-10-23.
**Revision 2.0 has been released. Revision 1.x is deprecated.**

Layouts:

 * ANSI/ISO with arrow keys main
 * AEK-II Alps secondary

Keyboard Layout Editor layout: http://tinyurl.com/ai03-voyager 
 
# Features
 
 * ANSI/ISO enter/shift, split/unified backspace
 * Optional LED backlighting
 * Optional RGB underglow
 * Recommended layout firmware available for a quick "build and use" solution
 * Follows good practices for circuitry design for a stable, reliable result
 * Fuse prevents mistakes in assembly from blowing up a computer (hopefully)

# Things required for assembly of a full keyboard

 * 66 switches, or less depending on layout
 * Case, keycaps, cable, stabilizers, plate
 * The PCB itself
 * Soldering iron, solder, flux
 * Desoldering wick/solder sucker for mistakes
 * Soldering skill for surface-mount devices
 * Parts in the parts list, and optional parts lists

# The parts list

 * 2	22pf 0805 capacitors
 * 1 	1uF 0805 capacitors
 * 2	0.1uF 0805 capacitors
 * 1	4.7uF 0805 capacitors
 * 66	SMA diodes (DO-214AC)
 * 1	PTC Fuse, 500mA hold current, 1206
 * 2	10k ohm 0805 resistors
 * 2	22 ohm 0805 resistors
 * 1	1.5k ohm 0805 resistors
 * 1	6x6mm through-hole push button
 * 1	ATMega32u2 - TQFP housing (NOT QFN)
 * 1	Molex-0548190589 Mini-USB connector
 * 1	16MHz 3.2x2.5mm crystal
 
# Optional per-key LED lighting:

 * 66	LEDs - 2x3x4mm or 1.8mm
 * 66	2.2-3.3k ohm 0805 resistors (2.7k recommended)
 * 1	SOT-223 NPN Transistor (NSS40301MZ4T1G recommended)
 
# Optional RGB underglow:

 * 14	WS2812B RGB LEDs (4-pin) for direct install
 * 14	0.1uF 0805 capacitors 
   or
 * 2	WS2812B-based RGB strips for mounted install (Recommended 7 LEDs per row x2)
 * 3	Regular thin wire to connect the strips to PCB

## KiCad design Voyager.kicad_pcb

Parts:
C1, C2: 22p; C_0805_HandSoldering
C3: 1uF; C_0805_HandSoldering
C4, C5: 0.1u; C_0805_HandSoldering
C6: 4.7u; C_0805_HandSoldering
CR1, CR2, CR3, CR4, CR5, CR6, CR7, CR8, CR9, CR10, CR11, CR12, CR13, CR14: 0.1u; C_0805_HandSoldering
F1: 500mA; Fuse_SMD1206_HandSoldering
Q1: NSS40301MZ4T1G; SOT-223-3_TabPin2
R1, R5: 10k; R_0805_HandSoldering
R2, R3: 22; R_0805_HandSoldering
R4: 1.5k; R_0805_HandSoldering
RGB1, RGB2, RGB3, RGB4, RGB5, RGB6, RGB7, RGB8, RGB9, RGB10, RGB11, RGB12, RGB13, RGB14: WS2812B
SW1: SW_PUSH; PushButton_6x6mm_TH
U1: ATMEGA32U2-AU; TQFP-32_7x7mm_Pitch0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C4.1, C5.1, C6.1, CR1.1, CR2.1, CR3.1, CR4.1, CR5.1, CR6.1, CR7.1, CR8.1, CR9.1, CR10.1, CR11.1, CR12.1, CR13.1, CR14.1, F1.1, R1.1, RGB1.1 (VCC), RGB2.1 (VCC), RGB3.1 (VCC), RGB4.1 (VCC), RGB5.1 (VCC), RGB6.1 (VCC), RGB7.1 (VCC), RGB8.1 (VCC), RGB9.1 (VCC), RGB10.1 (VCC), RGB11.1 (VCC), RGB12.1 (VCC), RGB13.1 (VCC), RGB14.1 (VCC), U1.4 (VCC), U1.31 (UVCC), U1.32 (AVCC); also elsewhere on the board
/D_N: R3.1, U1.30 (D-)
/D_P: R2.1, U1.29 (D+)
COL0: U1.6 ((OC.0B/INT0)PD0); also elsewhere on the board
COL1: U1.5 ((PCINT11/AIN2)PC2); also elsewhere on the board
COL2: U1.8 ((RXD1/AIN1/INT2)PD2); also elsewhere on the board
COL3: U1.23 ((OC.1A/PCINT8)PC6); also elsewhere on the board
COL4: U1.17 ((PD0/MISO/PCINT3)PB3); also elsewhere on the board
COL5: U1.18 ((T1/PCINT4)PB4); also elsewhere on the board
COL6: U1.19 ((PCINT5)PB5); also elsewhere on the board
COL7: U1.20 ((PCINT6)PB6); also elsewhere on the board
DM: R3.2, USB1.4 (D-)
DP: R2.2, USB1.3 (D+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, CR1.2, CR2.2, CR3.2, CR4.2, CR5.2, CR6.2, CR7.2, CR8.2, CR9.2, CR10.2, CR11.2, CR12.2, CR13.2, CR14.2, Q1.3 (E), R5.1, RGB1.3 (GND), RGB2.3 (GND), RGB3.3 (GND), RGB4.3 (GND), RGB5.3 (GND), RGB6.3 (GND), RGB7.3 (GND), RGB8.3 (GND), RGB9.3 (GND), RGB10.3 (GND), RGB11.3 (GND), RGB12.3 (GND), RGB13.3 (GND), RGB14.3 (GND), SW1.1, U1.3 (GND), U1.28 (UGND), USB1.1 (GND), Y1.2, Y1.4
LEDGND: Q1.2 (C); also elsewhere on the board
unnamed: C1.1, U1.1 (XTAL1), Y1.1
unnamed: C2.1, U1.2 (PC0(XTAL2)), Y1.3
unnamed: C3.1, U1.27 (UCAP)
unnamed: Q1.1 (B), R4.1
unnamed: R1.2, SW1.2, U1.24 (PC1(~RESET~/dW))
unnamed: R4.2, U1.21 ((PCINT7/OC.0A/OC.1C)PB7)
unnamed: R5.2, U1.13 ((~CTS~/~HWB~/AIN6/T0/INT7)PD7)
unnamed: RGB1.2 (DOUT), RGB2.4 (DIN)
unnamed: RGB2.2 (DOUT), RGB3.4 (DIN)
unnamed: RGB3.2 (DOUT), RGB4.4 (DIN)
unnamed: RGB4.2 (DOUT), RGB5.4 (DIN)
unnamed: RGB5.2 (DOUT), RGB6.4 (DIN)
unnamed: RGB6.2 (DOUT), RGB7.4 (DIN)
unnamed: RGB7.2 (DOUT), RGB8.4 (DIN)
unnamed: RGB8.2 (DOUT), RGB9.4 (DIN)
unnamed: RGB10.2 (DOUT), RGB11.4 (DIN)
unnamed: RGB9.2 (DOUT), RGB10.4 (DIN)
unnamed: RGB11.2 (DOUT), RGB12.4 (DIN)
unnamed: RGB12.2 (DOUT), RGB13.4 (DIN)
unnamed: RGB13.2 (DOUT), RGB14.4 (DIN)
RGBLED: RGB1.4 (DIN), U1.22 ((INT4/ICP1/CLK0)PC7)
ROW2: U1.14 ((~SS~/PCINT0)PB0); also elsewhere on the board
ROW3: U1.12 ((~RTS~/AIN5/INT6)PD6); also elsewhere on the board
ROW4: U1.11 ((XCK/AIN4/PCINT12)PD5); also elsewhere on the board
ROW7: U1.7 ((AIN0/INT1)PD1); also elsewhere on the board
ROW8: U1.25 ((PCINT9/OC.1B)PC5); also elsewhere on the board
ROW9: U1.26 ((PCINT10)PC4); also elsewhere on the board
VCC: F1.2, USB1.5 (VBUS)

Notes on the sheet:
Voyager Keyboard
2017-10-15
This is supposed to be a NPN transistor For some reason KiCad keeps flipping the arrow the other way
1.0

Parts:
D_#0_1, D_#1, D_#2, D_#3, D_#4, D_#5, D_#6, D_#7, D_#8, D_#9: SMA-GENERIC; D_SMA
D_'1: SMA-GENERIC; D_SMA
D_,1: SMA-GENERIC; D_SMA
D_-1: SMA-GENERIC; D_SMA
D_.1: SMA-GENERIC; D_SMA
D_/1: SMA-GENERIC; D_SMA
D_;1: SMA-GENERIC; D_SMA
D_=1: SMA-GENERIC; D_SMA
D_A1: SMA-GENERIC; D_SMA
D_ALT1: SMA-GENERIC; D_SMA
D_B1: SMA-GENERIC; D_SMA
D_BACK1: SMA-GENERIC; D_SMA
D_C1: SMA-GENERIC; D_SMA
D_CAPS1: SMA-GENERIC; D_SMA
D_CTRL1: SMA-GENERIC; D_SMA
D_D1: SMA-GENERIC; D_SMA
D_DEL1: SMA-GENERIC; D_SMA
D_DOWN1: SMA-GENERIC; D_SMA
D_E1: SMA-GENERIC; D_SMA
D_ENTER1: SMA-GENERIC; D_SMA
D_ESC1: SMA-GENERIC; D_SMA
D_F1: SMA-GENERIC; D_SMA
D_FN1: SMA-GENERIC; D_SMA
D_G1: SMA-GENERIC; D_SMA
D_H1: SMA-GENERIC; D_SMA
D_I1: SMA-GENERIC; D_SMA
D_ISO\1: SMA-GENERIC; D_SMA
D_ISO`1: SMA-GENERIC; D_SMA
D_J1: SMA-GENERIC; D_SMA
D_K1: SMA-GENERIC; D_SMA
D_L1: SMA-GENERIC; D_SMA
D_LEFT1: SMA-GENERIC; D_SMA
D_M1: SMA-GENERIC; D_SMA
D_N1: SMA-GENERIC; D_SMA
D_O1: SMA-GENERIC; D_SMA
D_P1: SMA-GENERIC; D_SMA
D_Q1: SMA-GENERIC; D_SMA
D_R1: SMA-GENERIC; D_SMA
D_RIGHT1: SMA-GENERIC; D_SMA
D_RSHIFT1: SMA-GENERIC; D_SMA
D_S1: SMA-GENERIC; D_SMA
D_SHIFT1: SMA-GENERIC; D_SMA
D_SPACE1: SMA-GENERIC; D_SMA
D_T1: SMA-GENERIC; D_SMA
D_TAB1: SMA-GENERIC; D_SMA
D_U1: SMA-GENERIC; D_SMA
D_UP1: SMA-GENERIC; D_SMA
D_V1: SMA-GENERIC; D_SMA
D_W1: SMA-GENERIC; D_SMA
D_WIN1: SMA-GENERIC; D_SMA
D_X1: SMA-GENERIC; D_SMA
D_Y1: SMA-GENERIC; D_SMA
D_Z1: SMA-GENERIC; D_SMA
D_[1: SMA-GENERIC; D_SMA
D_\1: SMA-GENERIC; D_SMA
D_]1: SMA-GENERIC; D_SMA
D_`1: SMA-GENERIC; D_SMA
K_#0_1, K_#1, K_#2, K_#3, K_#4, K_#5, K_#6, K_#7, K_#8, K_#9: MX-1U
K_'1: MX-1U
K_,1: MX-1U
K_-1: MX-1U
K_.1: MX-1U
K_/1: MX-1.75U
K_/2: MX-1U
K_;1: MX-1U
K_=1: MX-1U
K_A1: MX-1U
K_ALT1: MX-1.25U
K_ALT2: MX-1.25U; MX-1.25U-FLIPPED
K_B1: MX-1U
K_BACK1: MX-1U
K_BACK2: MX-2U
K_C1: MX-1U
K_CAPS1: MX-1.75U
K_CAPS2: MX-1.25U; MX-1.25U-FLIPPED
K_CMD1: MX-1.5U
K_CTRL1: MX-1.25U
K_CTRL2: MX-1.5U; MX-1.5U-FLIPPED
K_D1: MX-1U
K_DEL1: MX-1U
K_DOWN1: MX-1U
K_E1: MX-1U
K_ENTER1: MX-2.25U
K_ESC1: MX-1U
K_F1: MX-1U
K_FN1: MX-1U
K_G1: MX-1U
K_H1: MX-1U
K_I1: MX-1U
K_ISOENTER1: MX-ISO; MX-ISO-Combined-ReversedStabilizers
K_ISO\1: MX-1U
K_ISO`1: MX-1U
K_J1: MX-1U
K_K1: MX-1U
K_L1: MX-1U
K_LEFT1: MX-1U
K_M1: MX-1U
K_N1: MX-1U
K_O1: MX-1U
K_P1: MX-1U
K_Q1: MX-1U
K_R1: MX-1U
K_RALT1: MX-1.25U
K_RCTRL2: MX-1.5U; MX-1.5U-FLIPPED
K_RIGHT1: MX-1U
K_RSHIFT1: MX-1U
K_RSHIFT2: MX-2.75U
K_S1: MX-1U
K_SHIFT1: MX-2.25U
K_SHIFT2: MX-1.25U
K_SPACE1: MX-6.25U-FLIPPED; MX-6.25U-ReversedStabilizers
K_SPACE2: MX-6.5U
K_T1: MX-1U
K_TAB1: MX-1.5U
K_U1: MX-1U
K_UP1: MX-1U
K_V1: MX-1U
K_W1: MX-1U
K_WIN1: MX-1.25U
K_X1: MX-1U
K_Y1: MX-1U
K_Z1: MX-1U
K_[1: MX-1U
K_\1: MX-1.5U
K_]1: MX-1U
K_`1: MX-1U
R_#0_1, R_#1, R_#2, R_#3, R_#4, R_#5, R_#6, R_#7, R_#8, R_#9: 2.7k; R_0805_HandSoldering
R_'1: 2.7k; R_0805_HandSoldering
R_,1: 2.7k; R_0805_HandSoldering
R_-1: 2.7k; R_0805_HandSoldering
R_.1: 2.7k; R_0805_HandSoldering
R_/1: 2.7k; R_0805_HandSoldering
R_;1: 2.7k; R_0805_HandSoldering
R_=1: 2.7k; R_0805_HandSoldering
R_A1: 2.7k; R_0805_HandSoldering
R_ALT1: 2.7k; R_0805_HandSoldering
R_B1: 2.7k; R_0805_HandSoldering
R_BACK1: 2.7k; R_0805_HandSoldering
R_C1: 2.7k; R_0805_HandSoldering
R_CAPS1: 2.7k; R_0805_HandSoldering
R_CTRL1: 2.7k; R_0805_HandSoldering
R_D1: 2.7k; R_0805_HandSoldering
R_DEL1: 2.7k; R_0805_HandSoldering
R_DOWN1: 2.7k; R_0805_HandSoldering
R_E1: 2.7k; R_0805_HandSoldering
R_ENTER1: 2.7k; R_0805_HandSoldering
R_ESC1: 2.7k; R_0805_HandSoldering
R_F1: 2.7k; R_0805_HandSoldering
R_FN1: 2.7k; R_0805_HandSoldering
R_G1: 2.7k; R_0805_HandSoldering
R_H1: 2.7k; R_0805_HandSoldering
R_I1: 2.7k; R_0805_HandSoldering
R_ISO\1: 2.7k; R_0805_HandSoldering
R_ISO`1: 2.7k; R_0805_HandSoldering
R_J1: 2.7k; R_0805_HandSoldering
R_K1: 2.7k; R_0805_HandSoldering
R_L1: 2.7k; R_0805_HandSoldering
R_LEFT1: 2.7k; R_0805_HandSoldering
R_M1: 2.7k; R_0805_HandSoldering
R_N1: 2.7k; R_0805_HandSoldering
R_O1: 2.7k; R_0805_HandSoldering
R_P1: 2.7k; R_0805_HandSoldering
R_Q1: 2.7k; R_0805_HandSoldering
R_R1: 2.7k; R_0805_HandSoldering
R_RIGHT1: 2.7k; R_0805_HandSoldering
R_RSHIFT1: 2.7k; R_0805_HandSoldering
R_S1: 2.7k; R_0805_HandSoldering
R_SHIFT1: 2.7k; R_0805_HandSoldering
R_SPACE1: 2.7k; R_0805_HandSoldering
R_T1: 2.7k; R_0805_HandSoldering
R_TAB1: 2.7k; R_0805_HandSoldering
R_U1: 2.7k; R_0805_HandSoldering
R_UP1: 2.7k; R_0805_HandSoldering
R_V1: 2.7k; R_0805_HandSoldering
R_W1: 2.7k; R_0805_HandSoldering
R_WIN1: 2.7k; R_0805_HandSoldering
R_X1: 2.7k; R_0805_HandSoldering
R_Y1: 2.7k; R_0805_HandSoldering
R_Z1: 2.7k; R_0805_HandSoldering
R_[1: 2.7k; R_0805_HandSoldering
R_\1: 2.7k; R_0805_HandSoldering
R_]1: 2.7k; R_0805_HandSoldering
R_`1: 2.7k; R_0805_HandSoldering

Connections:
+5V: K_#0_1.3 (LED), K_#1.3 (LED), K_#2.3 (LED), K_#3.3 (LED), K_#4.3 (LED), K_#5.3 (LED), K_#6.3 (LED), K_#7.3 (LED), K_#8.3 (LED), K_#9.3 (LED), K_'1.3 (LED), K_,1.3 (LED), K_-1.3 (LED), K_.1.3 (LED), K_/1.3 (LED), K_/2.3 (LED), K_;1.3 (LED), K_=1.3 (LED), K_A1.3 (LED), K_ALT1.3 (LED), K_ALT2.3 (LED), K_B1.3 (LED), K_BACK1.3 (LED), K_BACK2.3 (LED), K_C1.3 (LED), K_CAPS1.3 (LED), K_CAPS2.3 (LED), K_CMD1.3 (LED), K_CTRL1.3 (LED), K_CTRL2.3 (LED), K_D1.3 (LED), K_DEL1.3 (LED), K_DOWN1.3 (LED), K_E1.3 (LED), K_ENTER1.3 (LED), K_ESC1.3 (LED), K_F1.3 (LED), K_FN1.3 (LED), K_G1.3 (LED), K_H1.3 (LED), K_I1.3 (LED), K_ISOENTER1.3 (LED), K_ISO\1.3 (LED), K_ISO`1.3 (LED), K_J1.3 (LED), K_K1.3 (LED), K_L1.3 (LED), K_LEFT1.3 (LED), K_M1.3 (LED), K_N1.3 (LED), K_O1.3 (LED), K_P1.3 (LED), K_Q1.3 (LED), K_R1.3 (LED), K_RALT1.3 (LED), K_RCTRL2.3 (LED), K_RIGHT1.3 (LED), K_RSHIFT1.3 (LED), K_RSHIFT2.3 (LED), K_S1.3 (LED), K_SHIFT1.3 (LED), K_SHIFT2.3 (LED), K_SPACE1.3 (LED), K_SPACE2.3 (LED), K_T1.3 (LED), K_TAB1.3 (LED), K_U1.3 (LED), K_UP1.3 (LED), K_V1.3 (LED), K_W1.3 (LED), K_WIN1.3 (LED), K_X1.3 (LED), K_Y1.3 (LED), K_Z1.3 (LED), K_[1.3 (LED), K_\1.3 (LED), K_]1.3 (LED), K_`1.3 (LED); also elsewhere on the board
COL0: K_#1.1 (COL), K_ALT2.2 (COL), K_CAPS1.1 (COL), K_CAPS2.2 (COL), K_CTRL1.1 (COL), K_CTRL2.1 (ROW), K_ESC1.1 (COL), K_ISO\1.1 (COL), K_SHIFT1.1 (COL), K_SHIFT2.1 (COL), K_TAB1.1 (COL), K_WIN1.1 (COL); also elsewhere on the board
COL1: K_#2.1 (COL), K_#3.1 (COL), K_A1.1 (COL), K_ALT1.1 (COL), K_CMD1.2 (ROW), K_Q1.1 (COL), K_S1.1 (COL), K_W1.1 (COL), K_X1.1 (COL), K_Z1.1 (COL); also elsewhere on the board
COL2: K_#4.1 (COL), K_#5.1 (COL), K_C1.1 (COL), K_D1.1 (COL), K_E1.1 (COL), K_F1.1 (COL), K_R1.1 (COL), K_V1.1 (COL); also elsewhere on the board
COL3: K_#6.1 (COL), K_#7.1 (COL), K_B1.1 (COL), K_G1.1 (COL), K_H1.1 (COL), K_N1.1 (COL), K_SPACE1.2 (COL), K_SPACE2.1 (COL), K_T1.1 (COL), K_Y1.1 (COL); also elsewhere on the board
COL4: K_#8.1 (COL), K_#9.1 (COL), K_,1.1 (COL), K_I1.1 (COL), K_J1.1 (COL), K_K1.1 (COL), K_M1.1 (COL), K_U1.1 (COL); also elsewhere on the board
COL5: K_#0_1.1 (COL), K_-1.1 (COL), K_.1.1 (COL), K_/1.1 (COL), K_/2.2 (ROW), K_;1.1 (COL), K_FN1.1 (COL), K_L1.1 (COL), K_O1.1 (COL), K_P1.1 (COL), K_`1.1 (COL); also elsewhere on the board
COL6: K_'1.1 (COL), K_=1.1 (COL), K_DEL1.1 (COL), K_DOWN1.1 (COL), K_ISO`1.1 (COL), K_LEFT1.1 (COL), K_RALT1.2 (ROW), K_RSHIFT2.1 (COL), K_UP1.1 (COL), K_[1.1 (COL), K_]1.1 (COL); also elsewhere on the board
COL7: K_BACK1.1 (COL), K_BACK2.1 (COL), K_ENTER1.1 (COL), K_ISOENTER1.1 (COL), K_RCTRL2.2 (COL), K_RIGHT1.1 (COL), K_RSHIFT1.1 (COL), K_\1.1 (COL); also elsewhere on the board
LEDGND: R_#0_1.1, R_#1.1, R_#2.1, R_#3.1, R_#4.1, R_#5.1, R_#6.1, R_#7.1, R_#8.1, R_#9.1, R_'1.1, R_,1.1, R_-1.1, R_.1.1, R_/1.1, R_;1.1, R_=1.1, R_A1.1, R_ALT1.1, R_B1.1, R_BACK1.1, R_C1.1, R_CAPS1.1, R_CTRL1.1, R_D1.1, R_DEL1.1, R_DOWN1.1, R_E1.1, R_ENTER1.1, R_ESC1.1, R_F1.1, R_FN1.1, R_G1.1, R_H1.1, R_I1.1, R_ISO\1.1, R_ISO`1.1, R_J1.1, R_K1.1, R_L1.1, R_LEFT1.1, R_M1.1, R_N1.1, R_O1.1, R_P1.1, R_Q1.1, R_R1.1, R_RIGHT1.1, R_RSHIFT1.1, R_S1.1, R_SHIFT1.1, R_SPACE1.1, R_T1.1, R_TAB1.1, R_U1.1, R_UP1.1, R_V1.1, R_W1.1, R_WIN1.1, R_X1.1, R_Y1.1, R_Z1.1, R_[1.1, R_\1.1, R_]1.1, R_`1.1; also elsewhere on the board
unnamed: D_#0_1.2 (A), K_#0_1.2 (ROW)
unnamed: D_#1.2 (A), K_#1.2 (ROW)
unnamed: D_#2.2 (A), K_#2.2 (ROW)
unnamed: D_#3.2 (A), K_#3.2 (ROW)
unnamed: D_#4.2 (A), K_#4.2 (ROW)
unnamed: D_#5.2 (A), K_#5.2 (ROW)
unnamed: D_#6.2 (A), K_#6.2 (ROW)
unnamed: D_#7.2 (A), K_#7.2 (ROW)
unnamed: D_#8.2 (A), K_#8.2 (ROW)
unnamed: D_#9.2 (A), K_#9.2 (ROW)
unnamed: D_'1.2 (A), K_'1.2 (ROW)
unnamed: D_,1.2 (A), K_,1.2 (ROW)
unnamed: D_-1.2 (A), K_-1.2 (ROW)
unnamed: D_.1.2 (A), K_.1.2 (ROW)
unnamed: D_/1.2 (A), K_/1.2 (ROW), K_/2.1 (COL)
unnamed: D_;1.2 (A), K_;1.2 (ROW)
unnamed: D_=1.2 (A), K_=1.2 (ROW)
unnamed: D_A1.2 (A), K_A1.2 (ROW)
unnamed: D_ALT1.2 (A), K_ALT1.2 (ROW), K_CMD1.1 (COL)
unnamed: D_B1.2 (A), K_B1.2 (ROW)
unnamed: D_BACK1.2 (A), K_BACK1.2 (ROW), K_BACK2.2 (ROW)
unnamed: D_C1.2 (A), K_C1.2 (ROW)
unnamed: D_CAPS1.2 (A), K_CAPS1.2 (ROW), K_CAPS2.1 (ROW)
unnamed: D_CTRL1.2 (A), K_CTRL1.2 (ROW), K_CTRL2.2 (COL)
unnamed: D_D1.2 (A), K_D1.2 (ROW)
unnamed: D_DEL1.2 (A), K_DEL1.2 (ROW)
unnamed: D_DOWN1.2 (A), K_DOWN1.2 (ROW)
unnamed: D_E1.2 (A), K_E1.2 (ROW)
unnamed: D_ENTER1.2 (A), K_ENTER1.2 (ROW), K_ISOENTER1.2 (ROW)
unnamed: D_ESC1.2 (A), K_ESC1.2 (ROW)
unnamed: D_F1.2 (A), K_F1.2 (ROW)
unnamed: D_FN1.2 (A), K_FN1.2 (ROW)
unnamed: D_G1.2 (A), K_G1.2 (ROW)
unnamed: D_H1.2 (A), K_H1.2 (ROW)
unnamed: D_I1.2 (A), K_I1.2 (ROW)
unnamed: D_ISO\1.2 (A), K_ISO\1.2 (ROW)
unnamed: D_ISO`1.2 (A), K_ISO`1.2 (ROW)
unnamed: D_J1.2 (A), K_J1.2 (ROW)
unnamed: D_K1.2 (A), K_K1.2 (ROW)
unnamed: D_L1.2 (A), K_L1.2 (ROW)
unnamed: D_LEFT1.2 (A), K_LEFT1.2 (ROW), K_RALT1.1 (COL)
unnamed: D_M1.2 (A), K_M1.2 (ROW)
unnamed: D_N1.2 (A), K_N1.2 (ROW)
unnamed: D_O1.2 (A), K_O1.2 (ROW)
unnamed: D_P1.2 (A), K_P1.2 (ROW)
unnamed: D_Q1.2 (A), K_Q1.2 (ROW)
unnamed: D_R1.2 (A), K_R1.2 (ROW)
unnamed: D_RIGHT1.2 (A), K_RCTRL2.1 (ROW), K_RIGHT1.2 (ROW)
unnamed: D_RSHIFT1.2 (A), K_RSHIFT1.2 (ROW)
unnamed: D_S1.2 (A), K_S1.2 (ROW)
unnamed: D_SHIFT1.2 (A), K_SHIFT1.2 (ROW), K_SHIFT2.2 (ROW)
unnamed: D_SPACE1.2 (A), K_SPACE1.1 (ROW), K_SPACE2.2 (ROW)
unnamed: D_T1.2 (A), K_T1.2 (ROW)
unnamed: D_TAB1.2 (A), K_TAB1.2 (ROW)
unnamed: D_U1.2 (A), K_U1.2 (ROW)
unnamed: D_V1.2 (A), K_V1.2 (ROW)
unnamed: D_W1.2 (A), K_W1.2 (ROW)
unnamed: D_WIN1.2 (A), K_ALT2.1 (ROW), K_WIN1.2 (ROW)
unnamed: D_X1.2 (A), K_X1.2 (ROW)
unnamed: D_Y1.2 (A), K_Y1.2 (ROW)
unnamed: D_Z1.2 (A), K_Z1.2 (ROW)
unnamed: D_[1.2 (A), K_[1.2 (ROW)
unnamed: D_\1.2 (A), K_\1.2 (ROW)
unnamed: D_]1.2 (A), K_]1.2 (ROW)
unnamed: D_`1.2 (A), K_`1.2 (ROW)
unnamed: K_#0_1.4 (LEDGND), R_#0_1.2
unnamed: K_#1.4 (LEDGND), R_#1.2
unnamed: K_#2.4 (LEDGND), R_#2.2
unnamed: K_#3.4 (LEDGND), R_#3.2
unnamed: K_#4.4 (LEDGND), R_#4.2
unnamed: K_#5.4 (LEDGND), R_#5.2
unnamed: K_#6.4 (LEDGND), R_#6.2
unnamed: K_#7.4 (LEDGND), R_#7.2
unnamed: K_#8.4 (LEDGND), R_#8.2
unnamed: K_#9.4 (LEDGND), R_#9.2
unnamed: K_'1.4 (LEDGND), R_'1.2
unnamed: K_,1.4 (LEDGND), R_,1.2
unnamed: K_-1.4 (LEDGND), R_-1.2
unnamed: K_.1.4 (LEDGND), R_.1.2
unnamed: K_/1.4 (LEDGND), K_/2.4 (LEDGND), R_/1.2
unnamed: K_;1.4 (LEDGND), R_;1.2
unnamed: K_=1.4 (LEDGND), R_=1.2
unnamed: K_A1.4 (LEDGND), R_A1.2
unnamed: K_ALT1.4 (LEDGND), K_CMD1.4 (LEDGND), R_ALT1.2
unnamed: K_ALT2.4 (LEDGND), K_WIN1.4 (LEDGND), R_WIN1.2
unnamed: K_B1.4 (LEDGND), R_B1.2
unnamed: K_BACK1.4 (LEDGND), K_BACK2.4 (LEDGND), R_BACK1.2
unnamed: K_C1.4 (LEDGND), R_C1.2
unnamed: K_CAPS1.4 (LEDGND), K_CAPS2.4 (LEDGND), R_CAPS1.2
unnamed: K_CTRL1.4 (LEDGND), K_CTRL2.4 (LEDGND), R_CTRL1.2
unnamed: K_D1.4 (LEDGND), R_D1.2
unnamed: K_DEL1.4 (LEDGND), R_DEL1.2
unnamed: K_DOWN1.4 (LEDGND), R_DOWN1.2
unnamed: K_E1.4 (LEDGND), R_E1.2
unnamed: K_ENTER1.4 (LEDGND), K_ISOENTER1.4 (LEDGND), R_ENTER1.2
unnamed: K_ESC1.4 (LEDGND), R_ESC1.2
unnamed: K_F1.4 (LEDGND), R_F1.2
unnamed: K_FN1.4 (LEDGND), R_FN1.2
unnamed: K_G1.4 (LEDGND), R_G1.2
unnamed: K_H1.4 (LEDGND), R_H1.2
unnamed: K_I1.4 (LEDGND), R_I1.2
unnamed: K_ISO\1.4 (LEDGND), R_ISO\1.2
unnamed: K_ISO`1.4 (LEDGND), R_ISO`1.2
unnamed: K_J1.4 (LEDGND), R_J1.2
unnamed: K_K1.4 (LEDGND), R_K1.2
unnamed: K_L1.4 (LEDGND), R_L1.2
unnamed: K_LEFT1.4 (LEDGND), K_RALT1.4 (LEDGND), R_LEFT1.2
unnamed: K_M1.4 (LEDGND), R_M1.2
unnamed: K_N1.4 (LEDGND), R_N1.2
unnamed: K_O1.4 (LEDGND), R_O1.2
unnamed: K_P1.4 (LEDGND), R_P1.2
unnamed: K_Q1.4 (LEDGND), R_Q1.2
unnamed: K_R1.4 (LEDGND), R_R1.2
unnamed: K_RCTRL2.4 (LEDGND), K_RIGHT1.4 (LEDGND), R_RIGHT1.2
unnamed: K_RSHIFT1.4 (LEDGND), R_RSHIFT1.2
unnamed: K_S1.4 (LEDGND), R_S1.2
unnamed: K_SHIFT1.4 (LEDGND), K_SHIFT2.4 (LEDGND), R_SHIFT1.2
unnamed: K_SPACE1.4 (LEDGND), K_SPACE2.4 (LEDGND), R_SPACE1.2
unnamed: K_T1.4 (LEDGND), R_T1.2
unnamed: K_TAB1.4 (LEDGND), R_TAB1.2
unnamed: K_U1.4 (LEDGND), R_U1.2
unnamed: K_V1.4 (LEDGND), R_V1.2
unnamed: K_W1.4 (LEDGND), R_W1.2
unnamed: K_X1.4 (LEDGND), R_X1.2
unnamed: K_Y1.4 (LEDGND), R_Y1.2
unnamed: K_Z1.4 (LEDGND), R_Z1.2
unnamed: K_[1.4 (LEDGND), R_[1.2
unnamed: K_\1.4 (LEDGND), R_\1.2
unnamed: K_]1.4 (LEDGND), R_]1.2
unnamed: K_`1.4 (LEDGND), R_`1.2
ROW2: D_E1.1 (K), D_O1.1 (K), D_Q1.1 (K), D_T1.1 (K), D_U1.1 (K), D_[1.1 (K), D_\1.1 (K); also elsewhere on the board
ROW3: D_I1.1 (K), D_P1.1 (K), D_R1.1 (K), D_TAB1.1 (K), D_W1.1 (K), D_Y1.1 (K), D_]1.1 (K); also elsewhere on the board
ROW4: D_'1.1 (K), D_A1.1 (K), D_D1.1 (K), D_ENTER1.1 (K), D_G1.1 (K), D_J1.1 (K), D_L1.1 (K); also elsewhere on the board
ROW7: D_,1.1 (K), D_/1.1 (K), D_ISO\1.1 (K), D_N1.1 (K), D_UP1.1 (K), D_V1.1 (K), D_X1.1 (K); also elsewhere on the board
ROW8: D_ALT1.1 (K), D_CTRL1.1 (K), D_FN1.1 (K), D_LEFT1.1 (K), D_RIGHT1.1 (K), D_SPACE1.1 (K); also elsewhere on the board
ROW9: D_DOWN1.1 (K), D_WIN1.1 (K), D_`1.1 (K); also elsewhere on the board

Notes on the sheet:
Matrix
2017-10-16

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
Board: 2 copper layers, 285.0 x 94.6 mm, 255 parts (177 on the bottom side), 179 nets.

## Commit log

2017-10-16 Init project
2017-10-16 Add submodules required for project
2017-10-16 Add schematic libraries
2017-10-16 Forgot a line
2017-10-16 Update readme again
2017-10-16 Whoops
2017-10-16 Small things in the readme
2017-10-17 Begin work on circuitry
2017-10-17 Add keyboard parts submodule
2017-10-17 Finish setting up most of controller
    Also added RGB LED cluster
    Todo: RGB LED decoupling caps
2017-10-17 Create matrix sheet
    Also fill out sheet descriptors
2017-10-17 Add RGB Decoupling capacitors
    Also fix label on matrix sheet being misplaced
2017-10-17 Begin work on matrix
2017-10-17 Finish empty unwired matrix
2017-10-17 Adjust grid key quantity
2017-10-17 Finish renaming all MX units
2017-10-17 Update layout
2017-10-17 Move a key
2017-10-17 Update layout again
2017-10-17 Rename diodes
2017-10-17 Rename all resistors
2017-10-17 Wire cols and 5V rails of LEDs
2017-10-17 Wire LED GND
2017-10-17 Wire the rows
2017-10-18 Add PCB libraries
2017-10-18 Begin footprint associations with lib parts
2017-10-18 Add TMK library as submodule
2017-10-18 Import the TMK footprint libraries
2017-10-18 Finish linking lib parts to footprints
2017-10-18 Finalize schematic without wiring non-main keys
2017-10-18 Add amtra5's outline footprint
2017-10-18 Initialize the PCB with outline
2017-10-18 Adjust PCB design page size
2017-10-18 Create preliminary netlist
2017-10-18 Import netlist
2017-10-18 Begin construction of basic layout
2017-10-18 Row 1 switch layout of PCB
2017-10-18 Switch fp row 2
2017-10-18 Switch fp 3rd row
2017-10-19 Add missing 1.25U shift
2017-10-19 Finish primary bottom row switches
2017-10-19 Update Layout
    No need for default bottom row when
    - GH60 exists
    - Layers exists
2017-10-19 Organize remaining switches
2017-10-19 Replace some switch footprints with alps only for compatibility
2017-10-19 Remove default bottom row
    If you want it, use the GH60 >.>
    Also re-added MX compatibility to AEK row
2017-10-19 Save before merge bottom rows
2017-10-19 Move outline footprint into place
2017-10-19 Place controller and reset button
2017-10-19 Update MX submodule
2017-10-19 Prepare diodes for placement
    Todo: Change footprint to SMA (DO-214AC)
2017-10-19 Replace all the 1N4148 diodes with SMA diodes
    Surface mount size easy enough for most DIYers
2017-10-19 Reverse ISO stabilizer holes to fix major collision
2017-10-19 Replace SMA handsoldering with regular
    handsolder footprints were way too big
2017-10-19 Place 22ohm resistors and PTC
2017-10-19 Add SteppedCaps, More diodes
2017-10-19 Even more diodes
2017-10-19 Further diodes
2017-10-19 Remove K_RCMD1
    Overlapped perfectly with K_`1
    No need
2017-10-19 Finish diodes
2017-10-19 Change crystal
2017-10-19 Change crystal back
2017-10-19 Place and breakout the controller
2017-10-19 Finalize controller region with proper shielding
2017-10-20 Undo controller and move it upwards
2017-10-20 Finalize controller gnd
2017-10-20 Finish via fencing
2017-10-20 Fix LED resistor pinout
2017-10-20 Change RGBLED pin
2017-10-20 Temporary save of progress
    RGBs and stuff
2017-10-20 Place bottom row RGBs
2017-10-20 Place in the RGBs
2017-10-20 Update resistor sizes to 0805
    1206 handsoldering footprints are massive
2017-10-20 Finish placing all parts on board
2017-10-20 Mostly finish adjusting parts locations
2017-10-20 Remove some comment drawings
2017-10-20 3 Rows wired
2017-10-20 Wire some cols
2017-10-20 Wire some more LEDs
2017-10-20 Wire more LEDs
2017-10-20 Correct pinout for secondary layouts
2017-10-20 More col work
2017-10-20 Finish 5V, GND, LEDGND
2017-10-20 Connect probably all remaining diodes
2017-10-20 Fix RShift
2017-10-20 Finish connecting stuff
2017-10-20 Work on connecting MCU to grid
2017-10-20 Connect all cols
2017-10-20 Update layout yet again
    Add unit size labels
2017-10-20 Finalize netlist
2017-10-22 Rough draft complete
2017-10-22 Move copper fill to begin revisions
2017-10-22 Repair some 5V for consistency
2017-10-22 Many modifications to max out the ground fill
2017-10-22 This is as far as I got in a few days
2017-10-22 Fix all "Track near Via" DRC errors
2017-10-22 Fix all DRC errors
2017-10-22 Finalize before decoration
2017-10-22 Re-add via fencing
2017-10-22 Add own logo footprint
2017-10-22 Add small front logo
2017-10-22 Make all key labels legible
2017-10-22 Flip the clock around to correct orientation
2017-10-22 Nearly complete
2017-10-22 Warn users about KiCad being KiCad
2017-10-22 Generate some test gerbers
2017-10-22 Attempt to rename everything
2017-10-22 Move some silkscreen
2017-10-23 Add a proper license
    To prevent abuse of open-source
2017-10-23 Autosave seems to have removed itself
2017-10-23 Some rough silkscreen decorations
2017-10-23 Finalize front silkscreen
2017-10-23 Complete back silk, but deciding on logo location
2017-10-23 More silkscreen work
2017-10-23 Invert the silk logo
2017-10-23 Back silkscreen Rev 2
2017-10-23 Finalize silkscreen hopefully for the last time
2017-10-23 New renders
2017-10-23 Add image to readme
2017-10-23 Update readme with parts list
2017-10-23 Organize readme a tad more
2017-10-23 Tets
2017-10-23 Fix one more overlapping silkscreen on front
2017-10-23 Fix up front silkscreen yet again
    I bet this will go on forever
2017-10-23 Update render
2017-10-23 Cachebusting
2017-10-23 Update gerbers to latest
2017-10-23 Error checkin
2017-10-23 Move a trace for better shielding to outside world
2017-10-23 Move a resistor inwards
2017-10-23 Move yet another resistor inwards
2017-10-23 Move caps diode to more reasonable location
2017-10-23 Fix logo on backside
2017-10-23 Update notes on schematic for Voyager 1.0 release
2017-10-23 Finalize 1.0 with version text on PCB
2017-10-23 Finalize copper fill, finalize gerber files
2017-10-23 Update renders and readme to 1.0 release
2017-10-29 Regenerate Gerber
2017-10-29 Seems like something was modified
2017-10-29 CvPcb - Change all SMA diodes to SOD323-Handsoldering
2017-10-29 Unroute all for revisions
2017-10-29 Move some diodes
2017-10-29 Move more diodes and resistors
2017-10-29 Fix all placements of diodes and resistors
2017-10-29 Fix remaining diodes
    All diodes upright and facing same direction to reduce mistakes
2017-10-29 Wire rows
2017-10-29 Connect some resistors to leds
2017-10-29 Connect all resistors
2017-10-31 Connect a crap ton of traces
2017-10-31 Progress controller
2017-10-31 Switch pins, connect some bottom rows
2017-10-31 Work on controller breakout
2017-10-31 Even more progress
2017-10-31 Finalize revision 2.0
2017-10-31 Update renders
2017-10-31 Update Gerber files
2017-10-31 Generate BOM
2017-10-31 Update render on readme
2017-10-31 Update rev1 readme for rev2 release
2017-10-31 Update notice for deprecated rev1 branch
2017-12-06 Begin Revision 3
2017-12-06 Begin matrix once again
    Welcome to hell
